# Keil uVision project Tiva_C_series_Robot_1.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: car_manual_n_autonomous
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ./: main.c
  group src
    ./: GPIO.c SysTick_Delay.c PWM_Clock.c PWM0_0.c PWM0_4_5.c UART0.c UART3.c Ultra_Sonic.c
  group inc
    ./: GPIO.h SysTick_Delay.h PWM_Clock.h PWM0_0.h PWM0_4_5.h UART0.h UART3.h Ultra_Sonic.h Swarm.h
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.1
